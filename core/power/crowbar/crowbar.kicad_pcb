# Repository AllAboutCircuits/C-BISCUIT

File README.md:

# C-BISCUIT
C-BISCUIT is a modular DIY robotic vehicle design based on the Freescale i.MX6 Wandboard and the Robotic Operating System (ROS).

## KiCad design core/power/crowbar/crowbar.kicad_pcb

File core/power/README.md:

# Power

## TODO

* Select R, C if special (power, ESR, whatever)
* Mega-Fit footprints
* Mounting hole footprints
* Fuse
    * Select holder
    * Make footprint
* Inductor footprint
* IC footprints?
* PCB layout

Parts:
D1: LM431; SOT-23_Handsoldering
D2: RED; LED-5MM
F1: 3A; 3549-BLADE-CLIP
P1, P2, P3, P4: CONN_01X01; SolderWirePad_single_SMD_5x10mm
R1: 3.48K; R_0805_HandSoldering
R2: 2.49K; R_0805_HandSoldering
R3: 200; R_0805_HandSoldering
R4: 220; R_0805_HandSoldering
U1: BT137S; TO-252-2Lead

Connections:
/DEVICE: F1.2, P2.1, R1.1, R3.1, R4.1, U1.1 (MT1)
/SUPPLY: F1.1, P1.1
GND: D1.3 (A), D2.1, P3.1, P4.1, R2.1, U1.2 (MT2)
unnamed: D1.1 (K), R4.2, U1.3 (G)
unnamed: D1.2 (Ref), R1.2, R2.2
unnamed: D2.2, R3.2

Notes on the sheet:
Crowbar Circuit
Mechanical

Board: 2 copper layers, 13.0 x 37.2 mm, 12 parts (4 on the bottom side), 6 nets.

## KiCad design core/power/crowbar/buck-reg-5v.kicad_pcb

File core/README.md:

# Core
This contains all files for the core robot module. This is designed to be modular and act as a drop-in brain for the land-rover and quadcopter platforms.

Board: 2 copper layers, 33 parts (0 on the bottom side), 19 nets.

Parts:
C1, C10: 330pF; C_0805_HandSoldering
C2, C6: 0.01uF; C_0805_HandSoldering
C3, C7: 2.2uF; C_1812_HandSoldering
C4, C5: DNP; C_0805_HandSoldering
C8: 0.47uF; C_0805_HandSoldering
C9: 0.022uF; C_0805_HandSoldering
C11: 22uF; C_1210_HandSoldering
C12, C13: 150uF; TantalC_SizeD_EIA-7343_HandSoldering
D1: CSHD6-60C; TO-252-2Lead
D2: LM431; SOT-23_Handsoldering
F1: 3A; R_1206_HandSoldering
L1: 33uH; Inductor_EB_DR127
P1, P2: CONN_01X02; Conn_01x02_5.0mm_Phoenix_1935161
R1, R2: DNP; R_0805_HandSoldering
R3: 20.5K; R_0805_HandSoldering
R4: 49.9K; R_0805_HandSoldering
R5: 10; R_2512_HandSoldering
R6: 3.48K; R_0805_HandSoldering
R7: 2.49K; R_0805_HandSoldering
R8: 15.4K; R_0805_HandSoldering
R9: 4.99K; R_0805_HandSoldering
R10: 220; R_0805_HandSoldering
U1: LM25576; SOIC-20-1EP
U2: BT151S-500R; TO-252-2Lead
W1, W2: TP; Socket_Strip_Straight_1x01

Connections:
+5V: F1.2, P1.1, R6.1, R10.1, U2.2
/BAT_IN: C3.1, C7.1, P2.1, R1.1, U1.3, U1.4
/BST: C9.2, U1.20
/COMP: C4.1, R4.1, U1.6
/FB: C4.2, C6.2, R8.2, R9.1, U1.7
/IS: D1.1, D1.3, U1.15, U1.16
/OUT: C11.1, C12.1, C13.1, F1.1, L1.2, R8.1, U1.12
/RAMP: C1.2, U1.9
/RT: R3.1, U1.8
/SD: C5.1, R1.2, R2.1, U1.2, W1.1
/SS: C2.1, U1.11
/SW: C9.1, C10.2, D1.2, L1.1, U1.17, U1.18, U1.19
/SYNC: U1.5, W2.1
/VCC: C8.1, U1.1
GND: C1.1, C2.2, C3.2, C5.2, C7.2, C8.2, C11.2, C12.2, C13.2, D2.3, P1.2, P2.2, R2.2, R3.2, R5.2, R7.1, R9.2, U1.10, U1.13, U1.14, U1.EP, U2.1
unnamed: C6.1, R4.2
unnamed: C10.1, R5.1
unnamed: D2.1, R10.2, U2.3
unnamed: D2.2, R6.2, R7.2

File core/power/buck-reg-5v/mfg/bom.csv:

Reference, Value, Footprint, Datasheet, Power
U1,LM25576,C-BISCUIT:SOIC-20-1EP,
L1,33uH,C-BISCUIT:Inductor_EB_DR127,
D1,CSHD6-60C,TO_SOT_Packages_SMD:TO-252-2Lead,
C8,0.47uF,Capacitors_SMD:C_0805_HandSoldering,
C9,0.022uF,Capacitors_SMD:C_0805_HandSoldering,
C10,330pF,Capacitors_SMD:C_0805_HandSoldering,
R5,10,Resistors_SMD:R_2512_HandSoldering,,1W
R8,15.4K,Resistors_SMD:R_0805_HandSoldering,
R9,4.99K,Resistors_SMD:R_0805_HandSoldering,
C11,22uF,Capacitors_SMD:C_1210_HandSoldering,
C12,150uF,Capacitors_Tantalum_SMD:TantalC_SizeD_EIA-7343_HandSoldering,
C6,0.01uF,Capacitors_SMD:C_0805_HandSoldering,
R4,49.9K,Resistors_SMD:R_0805_HandSoldering,
C4,DNP,Capacitors_SMD:C_0805_HandSoldering,
C2,0.01uF,Capacitors_SMD:C_0805_HandSoldering,
R3,20.5K,Resistors_SMD:R_0805_HandSoldering,
R1,DNP,Resistors_SMD:R_0805_HandSoldering,
R2,DNP,Resistors_SMD:R_0805_HandSoldering,
C5,DNP,Capacitors_SMD:C_0805_HandSoldering,
C3,2.2uF,Capacitors_SMD:C_1812_HandSoldering,
C7,2.2uF,Capacitors_SMD:C_1812_HandSoldering,
P1,CONN_01X02,C-BISCUIT:Conn_01x02_5.0mm_Phoenix_1935161,
C1,330pF,Capacitors_SMD:C_0805_HandSoldering,
P2,CONN_01X02,C-BISCUIT:Conn_01x02_5.0mm_Phoenix_1935161,
W2,TP,Socket_Strips:Socket_Strip_Straight_1x01,
W1,TP,Socket_Strips:Socket_Strip_Straight_1x01,
C13,150uF,Capacitors_Tantalum_SMD:TantalC_SizeD_EIA-7343_HandSoldering,

## Commit log

2016-01-04 created basic folder hierarcy and some really basic README's
2016-01-08 added draft of intro article with pics and parts for core.
2016-01-09 Added tools lists
2016-01-09 Fixed minor typos
2016-01-09 added partial justification article
2016-01-09 added research section, created doc top-level directory
2016-01-20 added some datasheets and docs for WB quad
2016-01-21 Adding LM25567 reference design
2016-01-21 Added draft of power diagram; shore power
2016-01-21 Added empty kicad project for the buck coverter board. Probably will be based on TI TPS54394
2016-01-21 Flow charts and stuff for power stage
2016-01-21 finished article 0, working on wrong branch
2016-01-21 folder reorg
2016-01-21 Added Nick's author link to Article 0
2016-01-21 Changed tumbnail dims
2016-01-21 typo
2016-01-22 Made several parts, laid down reg crowbar circuit
2016-01-23 Added design justification article
2016-01-25 Added some pics, reworded a few things, added links
2016-01-25 Added article 1 thumbnail image and removed old document / hierarchy
2016-01-25 Laid out reg schematic, made LM25576 symbol, using Molex mega-fit conns
2016-01-25 Finished schematic. Added component values
2016-01-31 Finished part selection, footprints. Added parts to PCB
2016-02-01 Finished buck reg PCB but needs review (and M3 holes)
2016-02-01 Finished buck reg. Awaiting review
2016-02-02 Started article on buck reg
2016-02-02 forgot to add images and such
2016-02-02 Broke up power into more articles
2016-02-12 Finished 5V reg (no crowbar) and article to go with it
2016-02-12 Added mfg files. Still needs links to parts.
2016-02-12 links in BOM and zip file for mfg finalized.
2016-02-12 changed zip file to include design files
2016-02-13 modified gitignore to allow an untracked directory called .untracked
2016-02-24 Removed weird XML file and zipped project together
2016-02-24 Moved crowbar and bat-mon-swap into .untracked to clean up branch
2016-02-24 finished crowbar schematic and chose components
2016-02-26 Finished crowbar and generated mfg files
2016-02-29 Finished crowbar article and mfg files
2016-02-29 Small changes in Crowbar readme
2016-05-23 Modified gitignore to include kicad autosave files
2016-05-23 Moved power assembly stub into article folder
2016-05-28 Test
2016-05-28 Added some pixxx
2016-06-07 Added startup script for monitoring system
